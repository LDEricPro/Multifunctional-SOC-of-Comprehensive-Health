# Keil uVision project m3_for_arty_a7.uvprojx, settings and files
target m3_for_arty_a7 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\EXIN_HMI;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\libsrc\Exin_HMITX_v1_0\src
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM3/: system_ARTY_CM3.c
    ../cmsis/Device/Source/ARTY_CM3/ARM/: startup_ARTY_CM3.s
  group Standalone_v6_7
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/standalone_v6_7/src/: outbyte.c print.c xil_assert.c
  group Main
    ../main/: main.c atomic_asm.s atomic.c
  group GPIO
    ../gpio/: gpio.c
  group SPI
    ../spi/: spi.c
  group UART
    ../uart/: uart.c
  group Xilinx_GPIO
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/gpio_v4_4/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
  group Xilinx_SPI
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/spi_v4_4/src/: xspi.c xspi_g.c xspi_options.c xspi_selftest.c xspi_sinit.c xspi_stats.c
  group Xilinx_UART
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
  group EXIN_Timer
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_Timer_v1_0/src/: Exin_Timer.c Exin_Timer_selftest.c
  group EXIN_BEEP
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_beep_v1_0/src/: Exin_beep.c Exin_beep_selftest.c
  group EXIN_MPU
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_MPU6050_GYXX_v1_0/src/: Exin_MPU6050_GYXX.c Exin_MPU6050_GYXX_selftest.c
  group EXIN_ADC
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_ADC0832_v1_0/src/: Exin_ADC0832.c Exin_ADC0832_selftest.c
  group EXIN_MaxMin
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_MAXMIN2_v1_0/src/: Exin_MAXMIN2.c Exin_MAXMIN2_selftest.c
  group EXIN_DHT
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_dht11_v1_0/src/: Exin_dht11.c Exin_dht11_selftest.c
  group EXIN_HeartFre
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_HeartFre2_v1_0/src/: Exin_HeartFre2.c Exin_HeartFre2_selftest.c
  group EXIN_BreathLED
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/breath_led_v1_0/src/: breath_led.c breath_led_selftest.c
  group EXIN_StepCounter
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_StepCounter_debug_v1_0/src/: Exin_StepCounter_debug.c Exin_StepCounter_debug_selftest.c
  group EXIN_NOLINER
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_noliner2_v1_0/src/: Exin_noliner2.c Exin_noliner2_selftest.c
  group EXIN_IO_Printer
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_IO_printer_v1_0/src/: Exin_IO_printer.c Exin_IO_printer_selftest.c
  group EXIN_HMI
    ../EXIN_HMI/: EXIN_HMI.c
  group EXIN_UARTSend
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/Exin_HMITX_v1_0/src/: Exin_HMITX.c Exin_HMITX_selftest.c
target m3_for_arty_a7_sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 SIM_BUILD
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\main;..\platform;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry=Reset_Handler
target m3_for_arty_a7_v2c (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.0.2
